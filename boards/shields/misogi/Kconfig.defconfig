## boards/shields/misogi/Kconfig.defconfig
```kconfig
if SHIELD_MISOGI

config ZMK_KEYBOARD_NAME
    default "nice_nano_v2"

endif # SHIELD_MISOGI
```
